# Repository tabinohito/Small_digital_pseudo_lockinamp

## KiCad design Small_digital_pseudo_lockinamp.kicad_pcb

Parts:
C101, C102, C103, C105, C106, C107: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C104: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D101, D102, D103: WS2812B-V6; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
H101, H102, H103, H104: MountingHole; MountingHole_3.2mm_M3
IC101: NJM2732E; SOIC127P600X190-8N; Manufacturer_Part_Number NJM2732E; Mouser Part Number 513-NJM2732E
J101: RASPBERRY_PI_PICO; RPi_Pico_SMD_TH_Compact; Manufacturer_Part_Number RASPBERRY PI PICO
J102, J103, J104: XA_02P; JST_XA_S02B-XASK-1N-BN_BoardEdge
R101, R102, R105: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R103: 4k7; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R104: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW101: RESET; SW_TS-1088-AR02016
SW102: Button01; SW_PUSH_6mm
U101: MCP1541-TT; SOT-23

Connections:
+3V3: J101.36 (3V3(OUT)), R101.1; also elsewhere on the board
+5V: C101.2, C102.1, C103.2, C105.2, C106.2, D101.1 (VDD), D102.1 (VDD), D103.1 (VDD), IC101.8 (V+), J101.40 (VBUS), U101.1 (Vin); also elsewhere on the board
/1V65: IC101.6 (B_-INPUT), IC101.7 (B_OUTPUT); also elsewhere on the board
/4V096: IC101.1 (A_OUTPUT), IC101.2 (A_-INPUT); also elsewhere on the board
/ADC1_CS: J101.22 (GP17); also elsewhere on the board
/ADC1_EOC: J101.17 (GP13); also elsewhere on the board
/ADC1_SCLK: J101.24 (GP18); also elsewhere on the board
/ADC1_SDI: J101.25 (GP19); also elsewhere on the board
/ADC1_SDO: J101.21 (GP16); also elsewhere on the board
/ADC2_CS: J101.12 (GP9); also elsewhere on the board
/ADC2_EOC: J101.19 (GP14); also elsewhere on the board
/ADC2_SCLK: J101.14 (GP10); also elsewhere on the board
/ADC2_SDI: J101.15 (GP11); also elsewhere on the board
/ADC2_SDO: J101.11 (GP8); also elsewhere on the board
/ADC3_CS: J101.6 (GP4); also elsewhere on the board
/ADC3_EOC: J101.10 (GP7); also elsewhere on the board
/ADC3_SCLK: J101.7 (GP5); also elsewhere on the board
/ADC3_SDI: J101.9 (GP6); also elsewhere on the board
/ADC3_SDO: J101.5 (GP3); also elsewhere on the board
/ADC_CONVST: J101.16 (GP12); also elsewhere on the board
/ADC_RESET: J101.20 (GP15), R101.2; also elsewhere on the board
/ADC_amp1/TIA+: J103.2; also elsewhere on the board
/ADC_amp1/TIA-: J103.1; also elsewhere on the board
/ADC_amp2/TIA+: J104.2; also elsewhere on the board
/ADC_amp2/TIA-: J104.1; also elsewhere on the board
/ADC_amp/TIA+: J102.2; also elsewhere on the board
/BUTTON1: J101.27 (GP21), SW102.1
/LED_ws2812: D101.4 (DIN), J101.26 (GP20)
/MCU_RUN: J101.30 (RUN), SW101.1
/PDM_CH0: J101.1 (GP0); also elsewhere on the board
/PDM_CH1: J101.2 (GP1); also elsewhere on the board
/PDM_CH2: J101.4 (GP2); also elsewhere on the board
/TIA_GAIN_CS: J101.29 (GP22); also elsewhere on the board
/TIA_GAIN_MISO: J101.34 (GP28); also elsewhere on the board
/TIA_GAIN_MOSI: J101.32 (GP27); also elsewhere on the board
/TIA_GAIN_SCLK: J101.31 (GP26); also elsewhere on the board
unnamed: D101.2 (DOUT), D102.4 (DIN)
unnamed: D102.2 (DOUT), D103.4 (DIN)
unnamed: C104.1, IC101.3 (A_+INPUT), R102.1, U101.2 (Vout)
unnamed: C107.1, IC101.5 (B_+INPUT), R104.2, R105.1
unnamed: R102.2, R103.1
unnamed: R103.2, R104.1

Notes on the sheet:
BUTTON1: GP21、押下でLow / 内部プルアップ使用

Parts:
C201: 22u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C202, C204: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C203, C205: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
IC201: ADS8331IBPWR; SOP65P640X120-24N; Manufacturer_Part_Number ADS8331IBPWR; Mouser Part Number 595-ADS8331IBPWR

Connections:
+3V3: C202.1, C203.1, IC201.16 (VBD); also elsewhere on the board
+5V: C204.1, C205.1, IC201.17 (VA); also elsewhere on the board
/4V096: C201.1, IC201.18 (REF+); also elsewhere on the board
/ADC1_CS: IC201.11 (FS/~CS); also elsewhere on the board
/ADC1_EOC: IC201.9 (EOC/~INT/CDI); also elsewhere on the board
/ADC1_SCLK: IC201.10 (SCLK); also elsewhere on the board
/ADC1_SDI: IC201.12 (SDI); also elsewhere on the board
/ADC1_SDO: IC201.13 (SDO); also elsewhere on the board
/ADC_CONVST: IC201.15 (~CONVST); also elsewhere on the board
/ADC_RESET: IC201.8 (~RESET); also elsewhere on the board
/ADC_amp/PDM_TIA/AMP-: IC201.2 (IN2); also elsewhere on the board
/ADC_amp/PDM_TIA/TIA_OUT: IC201.24 (IN0); also elsewhere on the board
/ADC_amp/TIA+: IC201.1 (IN1); also elsewhere on the board
unnamed: IC201.21 (ADCIN), IC201.22 (MUXOUT)

Parts of its further copies:
C401, C601: 22u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C402, C404, C602, C604: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C403, C405, C603, C605: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
IC401, IC601: ADS8331IBPWR; SOP65P640X120-24N; Manufacturer_Part_Number ADS8331IBPWR; Mouser Part Number 595-ADS8331IBPWR

Connections of its further copies:
+3V3: C402.1, C403.1, C602.1, C603.1, IC401.16 (VBD), IC601.16 (VBD); also elsewhere on the board
+5V: C404.1, C405.1, C604.1, C605.1, IC401.17 (VA), IC601.17 (VA); also elsewhere on the board
/4V096: C401.1, C601.1, IC401.18 (REF+), IC601.18 (REF+); also elsewhere on the board
/ADC2_CS: IC401.11 (FS/~CS); also elsewhere on the board
/ADC2_EOC: IC401.9 (EOC/~INT/CDI); also elsewhere on the board
/ADC2_SCLK: IC401.10 (SCLK); also elsewhere on the board
/ADC2_SDI: IC401.12 (SDI); also elsewhere on the board
/ADC2_SDO: IC401.13 (SDO); also elsewhere on the board
/ADC3_CS: IC601.11 (FS/~CS); also elsewhere on the board
/ADC3_EOC: IC601.9 (EOC/~INT/CDI); also elsewhere on the board
/ADC3_SCLK: IC601.10 (SCLK); also elsewhere on the board
/ADC3_SDI: IC601.12 (SDI); also elsewhere on the board
/ADC3_SDO: IC601.13 (SDO); also elsewhere on the board
/ADC_CONVST: IC401.15 (~CONVST), IC601.15 (~CONVST); also elsewhere on the board
/ADC_RESET: IC401.8 (~RESET), IC601.8 (~RESET); also elsewhere on the board
/ADC_amp1/PDM_TIA/AMP-: IC401.2 (IN2); also elsewhere on the board
/ADC_amp1/PDM_TIA/TIA_OUT: IC401.24 (IN0); also elsewhere on the board
/ADC_amp1/TIA+: IC401.1 (IN1); also elsewhere on the board
/ADC_amp2/PDM_TIA/AMP-: IC601.2 (IN2); also elsewhere on the board
/ADC_amp2/PDM_TIA/TIA_OUT: IC601.24 (IN0); also elsewhere on the board
/ADC_amp2/TIA+: IC601.1 (IN1); also elsewhere on the board
unnamed: IC401.21 (ADCIN), IC401.22 (MUXOUT)
unnamed: IC601.21 (ADCIN), IC601.22 (MUXOUT)

Parts:
C801: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
IC801: MCP23S17-E/SS; SSOP-28_5.3x10.2mm_P0.65mm
R801: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Connections:
+3V3: C801.1, IC801.9 (VDD), R801.1; also elsewhere on the board
/ADC_RESET: IC801.18 (~RESET); also elsewhere on the board
/TIA0_GAIN_A: IC801.21 (GPA0); also elsewhere on the board
/TIA0_GAIN_B: IC801.22 (GPA1); also elsewhere on the board
/TIA1_GAIN_A: IC801.23 (GPA2); also elsewhere on the board
/TIA1_GAIN_B: IC801.24 (GPA3); also elsewhere on the board
/TIA2_GAIN_A: IC801.25 (GPA4); also elsewhere on the board
/TIA2_GAIN_B: IC801.26 (GPA5); also elsewhere on the board
/TIA_GAIN_CS: IC801.11 (~CS), R801.2; also elsewhere on the board
/TIA_GAIN_MISO: IC801.14 (SO); also elsewhere on the board
/TIA_GAIN_MOSI: IC801.13 (SI); also elsewhere on the board
/TIA_GAIN_SCLK: IC801.12 (SCK); also elsewhere on the board

Notes on the sheet:
TIAゲイン制御 / SPI I/Oエキスパンダ
FW: PIOまたはソフトウェアSPIでADCと独立して制御。 SPI mode 0、5MHz以下。GP22は通常GPIOでCSを制御。 OLATA (0x14) = 0x00 → IODIRA (0x00) = 0xC0。 OLATAのbit0..5で6本のSELを制御。 測定中はSELを保持し、切替後に整定待ち。
専用SPI: CS=GP22、SCLK=GP26、MOSI=GP27、MISO=GP28。 ADCとは信号線を分離。RESETのみ共通。A2:A0 = 000。 起動時は入力状態 + 各SELの100kプルダウンで全OFF。 GPA0/1 = CH0、GPA2/3 = CH1、GPA4/5 = CH2。 同一CHのA/Bは通常どちらか一方のみON。 抵抗交換後はC303と整定時間も確認。
RP2040のハードウェアSPIは2系統。 GP26/27/28のSPI1はADC2/3の端子群と同じ内部周辺回路。 独立制御にはPIO / ソフトウェアSPIを使う。

Parts:
C301: 150p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C302: 180p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C303: 470p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C304, C305: 220p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C306: 62p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C307, C308, C309, C311, C312: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C310: 10n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
IC301, IC302: TMUX1101DBV; SOT-23-5
IC303, IC304, IC305: NJM2732E; SOIC127P600X190-8N; Manufacturer_Part_Number NJM2732E; Mouser Part Number 513-NJM2732E
R301, R302: TBD; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; not fitted
R303, R304: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R305, R306, R307, R310, R311, R312, R313, R314, R315, R317, R318: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R308, R319: 4k7; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R309, R316: 6k2; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R320: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Connections:
+5V: C307.2, C308.2, C309.2, C311.1, C312.1, IC301.5 (V_{DD}), IC302.5 (V_{DD}), IC303.8 (V+), IC304.8 (V+), IC305.8 (V+); also elsewhere on the board
/1V65: R318.1, R320.1; also elsewhere on the board
/ADC_amp/PDM_TIA/AMP-: IC303.7 (B_OUTPUT), IC305.3 (A_+INPUT), R315.2, R317.1; also elsewhere on the board
/ADC_amp/PDM_TIA/PDM_SINE: C310.2, R305.2, R306.2, R320.2
/ADC_amp/PDM_TIA/TIA_OUT: IC305.7 (B_OUTPUT), R314.2; also elsewhere on the board
/ADC_amp/TIA+: IC303.1 (A_OUTPUT), R311.1; also elsewhere on the board
/PDM_CH0: R308.1; also elsewhere on the board
/TIA0_GAIN_A: IC301.4, R303.1; also elsewhere on the board
/TIA0_GAIN_B: IC302.4, R304.1; also elsewhere on the board
unnamed: C302.1, R308.2, R309.1
unnamed: C304.1, C305.1, R316.1, R319.2
unnamed: IC301.2, R301.1
unnamed: IC302.2, R302.1
unnamed: IC303.3 (A_+INPUT), R306.1, R307.1
unnamed: IC303.2 (A_-INPUT), R310.1, R311.2
unnamed: IC303.5 (B_+INPUT), R307.2, R310.2
unnamed: IC303.6 (B_-INPUT), R305.1, R315.1
unnamed: C301.1, IC304.3 (A_+INPUT), R309.2
unnamed: C302.2, IC304.1 (A_OUTPUT), IC304.2 (A_-INPUT), R319.1
unnamed: C306.1, IC304.5 (B_+INPUT), R316.2
unnamed: C304.2, C305.2, C310.1, IC304.6 (B_-INPUT), IC304.7 (B_OUTPUT)
unnamed: C303.2, IC301.1, IC302.1, IC305.1 (A_OUTPUT), R312.1, R313.2
unnamed: IC305.5 (B_+INPUT), R317.2, R318.2
unnamed: IC305.6 (B_-INPUT), R313.1, R314.1

Parts of its further copies:
C501, C701: 150p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C502, C702: 180p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C503, C703: 470p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C504, C505, C704, C705: 220p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C506, C706: 62p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C507, C508, C509, C511, C512, C707, C708, C709, C711, C712: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C510, C710: 10n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
IC501, IC502, IC701, IC702: TMUX1101DBV; SOT-23-5
IC503, IC504, IC505, IC703, IC704, IC705: NJM2732E; SOIC127P600X190-8N; Manufacturer_Part_Number NJM2732E; Mouser Part Number 513-NJM2732E
R501, R502, R701, R702: TBD; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; not fitted
R503, R504, R703, R704: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R505, R506, R507, R510, R511, R512, R513, R514, R515, R517, R518, R705, R706, R707, R710, R711, R712, R713, R714, R715, R717, R718: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R508, R519, R708, R719: 4k7; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R509, R516, R709, R716: 6k2; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R520, R720: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Connections of its further copies:
+5V: C507.2, C508.2, C509.2, C511.1, C512.1, C707.2, C708.2, C709.2, C711.1, C712.1, IC501.5 (V_{DD}), IC502.5 (V_{DD}), IC503.8 (V+), IC504.8 (V+), IC505.8 (V+), IC701.5 (V_{DD}), IC702.5 (V_{DD}), IC703.8 (V+), IC704.8 (V+), IC705.8 (V+); also elsewhere on the board
/1V65: R518.1, R520.1, R718.1, R720.1; also elsewhere on the board
/ADC_amp1/PDM_TIA/AMP-: IC503.7 (B_OUTPUT), IC505.3 (A_+INPUT), R515.2, R517.1; also elsewhere on the board
/ADC_amp1/PDM_TIA/PDM_SINE: C510.2, R505.2, R506.2, R520.2
/ADC_amp1/PDM_TIA/TIA_OUT: IC505.7 (B_OUTPUT), R514.2; also elsewhere on the board
/ADC_amp1/TIA+: IC503.1 (A_OUTPUT), R511.1; also elsewhere on the board
/ADC_amp1/TIA-: C503.1, IC505.2 (A_-INPUT), R501.2, R502.2, R512.2; also elsewhere on the board
/ADC_amp2/PDM_TIA/AMP-: IC703.7 (B_OUTPUT), IC705.3 (A_+INPUT), R715.2, R717.1; also elsewhere on the board
/ADC_amp2/PDM_TIA/PDM_SINE: C710.2, R705.2, R706.2, R720.2
/ADC_amp2/PDM_TIA/TIA_OUT: IC705.7 (B_OUTPUT), R714.2; also elsewhere on the board
/ADC_amp2/TIA+: IC703.1 (A_OUTPUT), R711.1; also elsewhere on the board
/ADC_amp2/TIA-: C703.1, IC705.2 (A_-INPUT), R701.2, R702.2, R712.2; also elsewhere on the board
/PDM_CH1: R508.1; also elsewhere on the board
/PDM_CH2: R708.1; also elsewhere on the board
/TIA1_GAIN_A: IC501.4, R503.1; also elsewhere on the board
/TIA1_GAIN_B: IC502.4, R504.1; also elsewhere on the board
/TIA2_GAIN_A: IC701.4, R703.1; also elsewhere on the board
/TIA2_GAIN_B: IC702.4, R704.1; also elsewhere on the board
unnamed: C502.1, R508.2, R509.1
unnamed: C504.1, C505.1, R516.1, R519.2
unnamed: C702.1, R708.2, R709.1
unnamed: C704.1, C705.1, R716.1, R719.2
unnamed: IC501.2, R501.1
unnamed: IC502.2, R502.1
unnamed: IC503.3 (A_+INPUT), R506.1, R507.1
unnamed: IC503.2 (A_-INPUT), R510.1, R511.2
unnamed: IC503.5 (B_+INPUT), R507.2, R510.2
unnamed: IC503.6 (B_-INPUT), R505.1, R515.1
unnamed: C501.1, IC504.3 (A_+INPUT), R509.2
unnamed: C502.2, IC504.1 (A_OUTPUT), IC504.2 (A_-INPUT), R519.1
unnamed: C506.1, IC504.5 (B_+INPUT), R516.2
unnamed: C504.2, C505.2, C510.1, IC504.6 (B_-INPUT), IC504.7 (B_OUTPUT)
unnamed: C503.2, IC501.1, IC502.1, IC505.1 (A_OUTPUT), R512.1, R513.2
unnamed: IC505.5 (B_+INPUT), R517.2, R518.2
unnamed: IC505.6 (B_-INPUT), R513.1, R514.1
unnamed: IC701.2, R701.1
unnamed: IC702.2, R702.1
unnamed: IC703.3 (A_+INPUT), R706.1, R707.1
unnamed: IC703.2 (A_-INPUT), R710.1, R711.2
unnamed: IC703.5 (B_+INPUT), R707.2, R710.2
unnamed: IC703.6 (B_-INPUT), R705.1, R715.1
unnamed: C701.1, IC704.3 (A_+INPUT), R709.2
unnamed: C702.2, IC704.1 (A_OUTPUT), IC704.2 (A_-INPUT), R719.1
unnamed: C706.1, IC704.5 (B_+INPUT), R716.2
unnamed: C704.2, C705.2, C710.1, IC704.6 (B_-INPUT), IC704.7 (B_OUTPUT)
unnamed: C703.2, IC701.1, IC702.1, IC705.1 (A_OUTPUT), R712.1, R713.2
unnamed: IC705.5 (B_+INPUT), R717.2, R718.2
unnamed: IC705.6 (B_-INPUT), R713.1, R714.1

Notes on the sheet:
IC301 / IC302 各ICの電源ピン直近に配置
切替用抵抗: 1608 (0603)、値未定 / DNP R308は常時帰還。抵抗値とC303は測定帯域に合わせて調整。

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
Board: 4 copper layers, 90.0 x 65.0 mm, 159 parts (0 on the bottom side), 107 nets.

File production/pcba/BOM_JLCPCB.csv:

Comment,Designator,Footprint,LCSC Part #
100nF 50V X7R CC0603KRX7R9BB104,"C101,C102,C103,C105,C106,C107,C202,C204,C307,C308,C309,C311,C312,C402,C404,C507,C508,C509,C511,C512,C602,C604,C707,C708,C709,C711,C712,C801",0603,C14663
1uF 50V X5R CL10A105KB8NNNC,"C104,C203,C205,C403,C405,C603,C605",0603,C15849
22uF 16V X5R CGA0603X5R226M160JT,"C201,C401,C601",0603,C6119868
150pF 50V C0G 5% CL10C151JB8NNNC,"C301,C501,C701",0603,C37298
180pF 50V C0G 5% CL10C181JB8NNNC,"C302,C502,C702",0603,C17096
470pF 50V C0G 5% CL10C471JB81PNC,"C303,C503,C703",0603,C472795
220pF 50V C0G 5% CC0603JRNPO9BN221,"C304,C305,C504,C505,C704,C705",0603,C106210
10nF 50V X7R 0603B103K500NT,"C310,C510,C710",0603,C57112
WS2812B-V6,"D101,D102,D103",LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm,C52917433
MCP23S17-E/SS,IC801,SSOP-28_5.3x10.2mm_P0.65mm,C148009
S02B-XASS-1N-BN(LF)(SN),"J102,J103,J104",JST_XA_S02B-XASK-1N-BN_BoardEdge,C161669
10k ohm 1% 0603WAF1002T5E,"R101,R102,R105,R305,R306,R307,R310,R311,R312,R313,R314,R315,R317,R318,R505,R506,R507,R510,R511,R512,R513,R514,R515,R517,R518,R705,R706,R707,R710,R711,R712,R713,R714,R715,R717,R718,R801",0603,C25804
4.7k ohm 1% 0603WAF4701T5E,"R103,R308,R319,R508,R519,R708,R719",0603,C23162
120 ohm 1% 0603WAF1200T5E,R104,0603,C22787
100k ohm 1% 0603WAF1003T5E,"R303,R304,R503,R504,R703,R704",0603,C25803
6.2k ohm 1% 0603WAF6201T5E,"R309,R316,R509,R516,R709,R716",0603,C4260
1k ohm 1% 0603WAF1001T5E,"R320,R520,R720",0603,C21190
TS-1088-AR02016,SW101,SW_TS-1088-AR02016,C720477
MLD-TS-6X6X5-J,SW102,SW_PUSH_6mm,C52750873
MCP1541T-I/TT,U101,SOT-23,C7375
